# Repository mgerczuk/PCB-ESP32-power

## KiCad design pcb-esp32-power.kicad_pcb

Parts:
D1: LED green; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: C-OBD-II-16M; COMTECH_C-OBD-II-16M; PARTREV A
J2: Bus_Connector; PinHeader
J3: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R1: 200k; R_0603_1608Metric
R2: 390k; R_0603_1608Metric
R3: 1K; R_0603_1608Metric
R4, R5: 470k; R_0603_1608Metric

Connections:
5VIN: R1.1; also elsewhere on the board
+3V3: J2.1 (3V3); also elsewhere on the board
+12V: J1.16; also elsewhere on the board
+BATT: J3.1, R4.1; also elsewhere on the board
BATTVOLT: J2.6 (IO35), R4.2, R5.1
CANH: J1.6, J2.15 (CANH)
CANL: J1.14, J2.16 (CANL)
EXTPOW: J2.5 (IO34), R1.2, R2.1
GND: D1.1 (K), J1.4, J1.5, J2.30 (GND), J3.2, R2.2, R5.2; also elsewhere on the board
INT: J2.11 (IO27)
LED: J2.8 (IO33), R3.1
unnamed: D1.2 (A), R3.2
SCL: J2.28 (IO22)
SDA: J2.25 (IO21)

Parts:
C1, C2: 10nF; C_0603_1608Metric
C3: 560pF; C_0603_1608Metric
C4: 33pF; C_0603_1608Metric
C14: 10uF; C_1206_3216Metric
C15: 22uF; C_1206_3216Metric
L1: 4.7uH; CKST0503
R6, R10: 1M; R_0603_1608Metric
R7: 33.2k; R_0603_1608Metric
R8: 200k; R_0603_1608Metric
R9: 10k; R_0603_1608Metric
R11: 576k; R_0603_1608Metric
R12: 15k; R_0603_1608Metric
U1: LTC3530EMS; MSOP-10_MS; MANUFACTURER_PART_NUMBER ltc3530ems

Connections:
5VOUT: C14.1, R6.1, U1.7 (VIN); also elsewhere on the board
+3V3: C15.1, R10.1, R12.1, U1.6 (VOUT); also elsewhere on the board
GND: C1.2, C2.2, C14.2, C15.2, R7.2, R8.2, R11.2, U1.5 (GND); also elsewhere on the board
unnamed: C1.1, R6.2, U1.8 (*SHDN/SS)
unnamed: C2.1, R8.1, U1.2 (BURST)
unnamed: C3.1, C4.2, R10.2, R11.1, U1.9 (FB)
unnamed: C3.2, R9.1
unnamed: C4.1, R12.2
unnamed: L1.1, U1.4 (SW2)
unnamed: L1.2, U1.3 (SW1)
unnamed: R7.1, U1.1 (RT)
unnamed: R9.2, U1.10 (VC)

Parts:
C5: 10pF; C_0603_1608Metric
C6: 4.7uF; C_1206_3216Metric; Mouser Part Number 81-GRM31CR71H475KA2L
C7: 330nF; C_0805_2012Metric; Mouser Part Number 81-GCM219R71H334KA5D
C8: 220pF; C_0603_1608Metric
C9: 0.1uF; C_0603_1608Metric
C10: 0.47uF; C_0603_1608Metric
C11: 100uF; C_1206_3216Metric
C12: 3.3uF; C_0603_1608Metric; Mouser Part Number 810-C1608X5R1C335KAC
C13: 68uF; C_1206_3216Metric; Mouser Part Number 810-C3216X5R1A686M1C
D2: 6.8V; D_SOD-123; Mouser Part Number 78-MMSZ5235B-G3-08
D3: B360A; D_SMA; Mouser Part Number 78-B360A-M3/61T
IC1: LTC4091EDJC#PBF; LTC4091EDJCPBF; Mouser Part Number 584-LTC4091EDJCPBF
JP1: Chrg Volt; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L2: 6.8uH; CKST0503
Q1: MMDT5551; SOT-363_SC-70-6; Mouser Part Number 621-MMDT5551-F
Q2, Q3: AO3415A; SOT-23
R13: 49.9k; R_0603_1608Metric; Mouser Part Number 71-CRCW0603-49.9K
R14, R15: 100k; R_0603_1608Metric
R16: 140k; R_0603_1608Metric; Mouser Part Number 603-RC0603FR-07140KL
R17: 15k; R_0603_1608Metric
R18: 200k; R_0603_1608Metric
R19: 40.2k; R_0603_1608Metric; Mouser Part Number 71-CRCW0603-40.2K
R20, R22: 10k; R_0603_1608Metric
R21: 10k B3450; R_0603_1608Metric
R23: 0.05R; R_0603_1608Metric; Mouser Part Number 603-PT0603FR-070R05L

Connections:
5VIN: C12.1, IC1.18 (HVOUT), L2.2, Q2.3 (D); also elsewhere on the board
5VOUT: C13.1, IC1.13 (OUT), Q2.2 (S), Q3.2 (S), R22.2; also elsewhere on the board
+12V: C6.1, D2.1 (K), IC1.21 (VIN), R15.1, R16.1; also elsewhere on the board
+BATT: IC1.11 (BAT_1), IC1.12 (BAT_2), JP1.2 (B), Q3.3 (D), R23.1; also elsewhere on the board
GND: C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, C13.2, D3.2 (A), IC1.1 (SYNC), IC1.15 (GND_1), IC1.23 (GND_2), IC1.24 (GND_3), IC1.25 (GND_4), Q1.1 (E1), Q1.4 (E2), R13.2, R18.2, R19.2, R21.2; also elsewhere on the board
unnamed: C5.1, IC1.4 (VC), R17.1
unnamed: C7.1, IC1.22 (RUN/SS), Q1.6 (C1), R16.2
unnamed: C8.1, R17.2
unnamed: C9.1, IC1.17 (TIMER)
unnamed: C10.1, D3.1 (K), IC1.20 (SW), L2.1
unnamed: C10.2, IC1.19 (BOOST)
unnamed: C11.1, R23.2
unnamed: D2.2 (A), R13.1, R14.2
unnamed: IC1.3 (RT), R19.1
unnamed: IC1.5 (NTC), R20.2, R21.1
unnamed: IC1.6 (VNTC), R20.1
unnamed: IC1.7 (~HVPR), Q2.1 (G), R22.1
unnamed: IC1.9 (PROG), R18.1
unnamed: IC1.10 (GATE), Q3.1 (G)
unnamed: IC1.14 (V4P1), JP1.1 (A)
unnamed: Q1.2 (B1), Q1.3 (C2), R15.2
unnamed: Q1.5 (B2), R14.1

Board: 2 copper layers, 52.6 x 47.4 mm, 52 parts (0 on the bottom side), 38 nets.

## KiCad design ip5108.kicad_pcb

Parts:
C6: 47pF; C_0603_1608Metric
CP8, CP9: 22uF; CP_EIA-6032-28_Kemet-C
IC2: SY8008B; SOT95P285X140-5N; Manufacturer_Part_Number SY8008B
J1: DB9_Female; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_H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
J2: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: Conn_01x14; PinSocket_1x14_P2.54mm_Vertical
J4: Conn_01x16; PinSocket_1x16_P2.54mm_Vertical
L2: 2.2uH; CD54NP470LC
R11, R12: 100k; R_0603_1608Metric
R13: 453k 1%; R_0603_1608Metric
R14: 100k 1%; R_0603_1608Metric
U1: STEPDOWN12_5; StepDownBreakout

Connections:
5VIN: U1.5 (OUT+), U1.6 (OUT+); also elsewhere on the board
5VOUT: IC2.4 (IN), R11.1; also elsewhere on the board
+3V3: C6.1, CP8.1, CP9.1, L2.1, R13.1
+12V: J1.9, U1.1 (IN+), U1.2 (IN+)
+BATT: J2.1; also elsewhere on the board
CANH: J1.7
CANL: J1.2
EXTPOW: J3.6; also elsewhere on the board
GND: CP8.2, CP9.2, IC2.2 (GND), J1.3, J1.6, J2.2, R12.2, R14.2, U1.3 (IN-), U1.4 (IN-), U1.7 (OUT-), U1.8 (OUT-); also elsewhere on the board
INT: J3.11
unnamed: C6.2, IC2.5 (FB), R13.2, R14.1
unnamed: IC2.1 (EN), R11.2, R12.1
unnamed: IC2.3 (LX), L2.2
SCL: J4.3; also elsewhere on the board
SDA: J4.6; also elsewhere on the board

Parts:
C1, C2, C4, C5: 104; C_0603_1608Metric
C3: 4.7nF; C_0603_1608Metric
CP1, CP3: 22uF; CP_EIA-6032-28_Kemet-C
CP2, CP4, CP5, CP6, CP7: 10uF; CP_EIA-3528-21_Kemet-B
IC1: IP5108; SOIC127P600X175-17N; Manufacturer_Part_Number IP5108
L1: 1uH; CD54NP470LC
R1: 2R; R_0603_1608Metric
R2: 1K; R_0603_1608Metric
R3, R4: 3.3k; R_0603_1608Metric
R5: 10mOhm; R_1206_3216Metric

Connections:
5VIN: C2.1, CP5.1, IC1.7, R1.2, R2.1; also elsewhere on the board
5VOUT: C1.1, C3.1, CP1.1, CP3.1, CP4.1, IC1.5, IC1.6; also elsewhere on the board
+BATT: C5.1, CP7.1, IC1.16, R5.1; also elsewhere on the board
GND: C1.2, C4.2, C5.2, CP1.2, CP2.2, CP3.2, CP4.2, CP6.2, CP7.2, IC1.2, IC1.8, IC1.14, IC1.17; also elsewhere on the board
IRQ: IC1.11
unnamed: C2.2, CP5.2, R2.2
unnamed: C3.2, IC1.3, IC1.4, L1.2
unnamed: C4.1, CP6.1, IC1.1, L1.1, R5.2
unnamed 15: IC1.12, R3.1, R4.1; also elsewhere on the board
unnamed: CP2.1, R1.1
SCL: IC1.9, R4.2; also elsewhere on the board
SDA: IC1.10, R3.2; also elsewhere on the board

Board: 2 copper layers, 75.0 x 34.0 mm, 36 parts (0 on the bottom side), 17 nets.

Other parts of the board:
C7: 2.2uF; C_0603_1608Metric
R6, R7: R; R_0603_1608Metric

Their connections:
5VIN: R6.1; also elsewhere on the board
EXTPOW: R6.2, R7.1; also elsewhere on the board
GND: C7.2, R7.2; also elsewhere on the board
unnamed 15: C7.1; also elsewhere on the board

## Commit log

2021-07-17 IP5108 in Unterschaltplan verschoben
2021-07-19 IP5108 in Unterverzeichnis verschoben
2021-07-20 Umbenannt
2021-07-20 ESP32 Bus verwendet
2021-07-23 Breite Platine mit SUB D
2021-07-23 Mit OBD II Stecker
2021-07-24 Gerbers erstellt
2021-07-26 Gerber mit korrekter Erweiterung
2021-08-06 Footprints für "Hand solder"
2021-08-27 Umstellung auf TP4054/SY8008/LTC3440
2021-09-03 LTC3530 eingefügt
2021-09-04 Mit SY8008
2021-09-04 Mit Sy8008 und LTC3530
2021-09-10 LED zugefügt
2021-09-27 OBD Pin 4 & 5 an Masse
2021-10-29 Erste Version mit LTC4091
2021-10-29 Keine "Handsolder" Footprints mehr
2021-11-05 Footprint Änderungen Kondensatoren & Induktoren
2021-11-05 Nochmal überarbeitet
2021-11-07 Massefläche + Kleinigkeiten
2021-11-09 Layout nochmal wg. kritischer Strompfade geändert
2021-11-09 Gerber erstellt
2021-12-10 Pads von LTC3530 verkleinert
